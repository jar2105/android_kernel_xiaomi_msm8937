## drivers/dts_eagle/Kconfig
```kconfig
config DTS_EAGLE
	bool "DTS Eagle driver"
	depends on ARM
	default y if ARM
	help
	  DTS Eagle module.
```
